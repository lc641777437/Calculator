# Keil uVision project 计算器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 计算器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.h delay.c 1602.c keyboard.h keyboard.c stack.h stack.c main.c includes.h
    ../新建文件夹 (2)/: STARTUP.A51
